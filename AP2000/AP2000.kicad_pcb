# Repository imagestream/kicad (continued)

## KiCad design AP2000/AP2000.kicad_pcb (continued)

Board: 4 copper layers, 108.0 x 110.0 mm, 152 parts (3 on the bottom side), 99 nets.

## KiCad design AP2100/AP2100v4.kicad_pcb

Board: 4 copper layers, 160.0 x 90.0 mm, 151 parts (6 on the bottom side), 204 nets.

Parts:
BT1: Battery_Cell; BatteryHolder_Keystone_3034_1x20mm
C1, C3, C4, C7, C11, C12, C13, C14, C15, C22, C23, C24, C29, C40, C46, C57, C58, C62: 100n; C_0402_1005Metric
C2, C5, C6, C10, C17, C19, C20, C21, C30, C31, C32, C33, C47, C49, C51, C52: 10u; C_0805_2012Metric
C8, C9: 27pF; C_0402_1005Metric
C16, C18, C45: 100uF; CP_EIA-7343-31_Kemet-D
C25, C26, C27, C28, C34, C35, C37, C38, C39, C41, C42, C43, C44: 10u 35v; C_0805_2012Metric
C36: 100n 100v; C_0402_1005Metric
C59, C61, C63, C65: nf; C_0402_1005Metric
C60, C64: 1.2nF; C_0402_1005Metric
D1: LED Red; LED_0603_1608Metric
D2: LED Green; LED_0603_1608Metric
D3: BAT54C-7-F; SOT-23
D4: MMBZ5242BLT3G; D_SOT-23_ANK
H1, H2, H3, H4, H5, H6, H7, H8: MountingHole; MountingHole_2.7mm_M2.5
J1, J3: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2: Conn_02x07_Odd_Even; PinHeader_2x07_P2.54mm_Vertical
J4, J5, J15, J16: Conn_01x22_Female; Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal
J6, J9: THD-02-R; PinHeader_2x02_P2.54mm_Vertical
J7: Micro_SD_Card_Det; SDCARD_MOLEX_503398-1892
J8: THD-20-R; PinHeader_2x20_P2.54mm_Vertical
J10, J22: 690-019-298-412; EDAC 690-019-298-412
J11: USB_OTG; USB_Micro-B_EDAC_UCON00686
J12: 10018783-11200TLF; PCIex1-36
J13: 690-008-221-904; MOLEX_USB_67298-4090
J14: Conn_02x05_Odd_Even; PinHeader_2x05_P2.54mm_Vertical
J17: Molex 470531000; FanPinHeader_1x04_P2.54mm_Vertical
J19: Barrel_Jack; BarrelJack_Horizontal
J20: AMP171826-4; TE_171826-4
L3, L5: SRN6045TA-3R3Y; L_Bourns_SRN6045TA
Module1: ComputeModule4; Raspberry-Pi-4-Compute-Module
Q1: DMP3013SFV-7; Diodes_PowerDI3333-8
R1, R10: 1k; R_0402_1005Metric
R2, R3: 470R; R_0402_1005Metric
R4: nf; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R5: 0R; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
R6, R7, R8, R11, R28: 2.2K 1%; R_0402_1005Metric
R9, R22: 10R; R_0402_1005Metric
R12, R13, R14, R16, R21: 36K 1%; R_0402_1005Metric
R15, R23, R26, R27, R29: 12K 1%; R_0402_1005Metric
R17, R18: nf; R_0402_1005Metric
R19, R20: 510K 1%; R_0402_1005Metric
R24: 47K 1%; R_0402_1005Metric
R25: 20K 1%; R_0402_1005Metric
R30, R36: 15K 1%; R_0402_1005Metric
TP1, TP2, TP3, TP4, TP5, TP6: TestPoint; TestPoint_Pad_2.0x2.0mm
U1, U2, U4: TPD4EUSB30; USON-10_2.5x1.0mm_P0.5mm
U3: MagJack-A70-112-331N126; TRJG0926HENL
U5, U9, U14: 74LVC1G07SE-7; SOT-353_SC-70-5
U6: USB2514B-I/M2; QFN-36-1EP_6x6mm_P0.5mm_EP3.7x3.7mm
U7: AP22653W6; SOT-23-6
U8: PCF85063AT/AAZ; SOIC-8_3.9x4.9mm_P1.27mm
U11: EMC2301-1-ACZL-TR; MSOP-8_3x3mm_P0.65mm
U12: RT9742SNGV; SOT-23
U13: FSUSB42MUX; MSOP-10_3x3mm_P0.5mm
U15, U16: AP64501SP-13; SOIC-8-1EP_3.9x4.9mm_P1.27mm_EP2.95x4.9mm_Mask2.71x3.4mm_Th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
U18: RT9742GGJ5; SOT-23-5
Y1: 24MHz; Crystal_SMD_HC49-SD
Y2: X32K768S301; Crystal_SMD_3215-2Pin_3.2x1.5mm

Connections:
/+3.3v: C3.1, C4.1, C6.1, C7.1, C10.1, C11.1, C14.1, C15.1, C23.1, D1.2 (A), D2.2 (A), D3.2, J4.22, J5.22, J8.1, J8.17, J15.22, J16.22, Module1.84 (+3.3v_(Output)), Module1.86 (+3.3v_(Output)), R5.1, R17.1, R21.2, R29.1, U3.15 (LEDY_A), U3.17 (LEDG_A), U5.5 (VCC), U6.5 (VDDA33), U6.10 (VDDA33), U6.15 (VDD33), U6.23 (VDD33), U6.27 (VBUS_DET), U6.29 (VDDA33), U6.36 (VDDA33), U11.3 (VDD), U13.1 (VCC), U18.5 (IN)
/+5v: C2.1, C12.1, C18.1, C22.1, C47.1, C49.1, C51.1, C52.1, C61.1, J8.2, J8.4, J20.4, L5.2, Module1.77 (+5v_(Input)), Module1.79 (+5v_(Input)), Module1.81 (+5v_(Input)), Module1.83 (+5v_(Input)), Module1.85 (+5v_(Input)), Module1.87 (+5v_(Input)), R19.2, R20.2, R27.1, TP4.1, U7.1 (IN), U9.5 (VCC), U12.1 (IN), U14.5 (VCC)
/+12v: C25.1, C26.1, C27.1, C28.1, C34.1, C35.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, D4.1 (K), J12.A2 (+12V), J12.A3 (+12V), J12.B1 (+12v), J12.B2 (+12v), J12.B3 (+12v), J17.2, J20.1, Q1.1 (S), Q1.2 (S), Q1.3 (S), TP2.1, U15.2 (VIN), U15.3 (EN), U16.2 (VIN), U16.3 (EN)
/CAM_GPIO: J4.17, J5.17, Module1.97 (Camera_GPIO)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/+1.8v: Module1.88 (+1.8v_(Output)), Module1.90 (+1.8v_(Output)), R4.1
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/AIN0: J2.5, Module1.96 (AnalogIP0)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/AIN1: J2.6, Module1.94 (AnalogIP1)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/BT_nDis: J3.3, Module1.91 (BT_nDisable)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/EEPROM_nWP: J2.4, Module1.20 (EEPROM_nWP)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/ETH_LEDG: Module1.15 (Ethernet_nLED3(3.3v)), R3.2
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/ETH_LEDY: Module1.17 (Ethernet_nLED2(3.3v)), R2.2
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO2: J8.3, Module1.58 (GPIO2)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO3: J8.5, Module1.56 (GPIO3)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO4: J8.7, Module1.54 (GPIO4)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO5: J8.29, Module1.34 (GPIO5)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO6: J8.31, Module1.30 (GPIO6)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO7: J8.26, Module1.37 (GPIO7)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO8: J8.24, Module1.39 (GPIO8)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO9: J8.21, Module1.40 (GPIO9)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO10: J8.19, Module1.44 (GPIO10)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO11: J8.23, Module1.38 (GPIO11)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO12: J8.32, Module1.31 (GPIO12)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO13: J8.33, Module1.28 (GPIO13)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO14: J8.8, Module1.55 (GPIO14)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO15: J8.10, Module1.51 (GPIO15)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO16: J8.36, Module1.29 (GPIO16)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO17: J8.11, Module1.50 (GPIO17)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO18: J8.12, Module1.49 (GPIO18)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO19: J8.35, Module1.26 (GPIO19)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO20: J8.38, Module1.27 (GPIO20)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO21: J8.40, Module1.25 (GPIO21)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO22: J8.15, Module1.46 (GPIO22)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO23: J8.16, Module1.47 (GPIO23)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO24: J8.18, Module1.45 (GPIO24)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO25: J8.22, Module1.41 (GPIO25)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO26: J8.37, Module1.24 (GPIO26)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/GPIO27: J8.13, Module1.48 (GPIO27)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/RUN_PG: J1.3, Module1.92 (RUN_PG), U9.2
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_CLK: J7.5 (CLK), Module1.57 (SD_CLK)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_CMD: J7.3 (CMD), Module1.62 (SD_CMD)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT0: J7.7 (DAT0), Module1.63 (SD_DAT0)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT1: J7.8 (DAT1), Module1.67 (SD_DAT1)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT2: J7.1 (DAT2), Module1.69 (SD_DAT2)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DAT3: J7.2 (DAT3/CD), Module1.61 (SD_DAT3)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_DET: Module1.76 (Reserved), R18.1
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_PWR: C5.1, J7.4 (VDD), U18.1 (OUT)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SD_PWR_ON: Module1.75 (SD_PWR_ON), R29.2, U18.4 (EN)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SYNC_IN: J2.8, Module1.16 (Ethernet_SYNC_IN(1.8v))
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/SYNC_OUT: J2.9, Module1.18 (Ethernet_SYNC_OUT(1.8v))
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TR0_TAP: J9.3, U3.11 (VC1)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TR1_TAP: J9.1, U3.12 (VC2)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TR2_TAP: J9.2, U3.13 (VC3)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TR3_TAP: J9.4, U3.14 (VC4)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD0_N: Module1.10 (Ethernet_Pair0_N), U2.4 (D2+), U2.7, U3.2 (TRD0-)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD0_P: Module1.12 (Ethernet_Pair0_P), U2.5 (D2-), U2.6, U3.1 (TRD0+)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD1_N: Module1.6 (Ethernet_Pair1_N), U2.2 (D1-), U2.9, U3.6 (TRD1-)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD1_P: Module1.4 (Ethernet_Pair1_P), U2.1 (D1+), U2.10, U3.3 (TRD1+)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD2_N: Module1.9 (Ethernet_Pair2_N), U1.4 (D2+), U1.7, U3.8 (TRD2-)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD2_P: Module1.11 (Ethernet_Pair2_P), U1.5 (D2-), U1.6, U3.7 (TRD2+)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD3_N: Module1.5 (Ethernet_Pair3_N), U1.2 (D1-), U1.9, U3.10 (TRD3-)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/TRD3_P: Module1.3 (Ethernet_Pair3_P), U1.1 (D1+), U1.10, U3.9 (TRD3+)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/WL_nDis: J3.1, Module1.89 (WL_nDisable)
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/nPWR_LED: Module1.95 (nPI_LED_PWR), U5.2
/CM4_GPIO ( Ethernet, GPIO, SDCARD)/nRPIBOOT: J2.2, Module1.93 (nRPIBOOT)
/CM4_HighSpeed/CAM0_C_N: J4.8, Module1.140 (CAM0_C_N)
/CM4_HighSpeed/CAM0_C_P: J4.9, Module1.142 (CAM0_C_P)
/CM4_HighSpeed/CAM0_D0_N: J4.2, Module1.128 (CAM0_D0_N)
/CM4_HighSpeed/CAM0_D0_P: J4.3, Module1.130 (CAM0_D0_P)
/CM4_HighSpeed/CAM0_D1_N: J4.5, Module1.134 (CAM0_D1_N)
/CM4_HighSpeed/CAM0_D1_P: J4.6, Module1.136 (CAM0_D1_P)
/CM4_HighSpeed/CAM1_C_N: J5.8, Module1.127 (CAM1_C_N)
/CM4_HighSpeed/CAM1_C_P: J5.9, Module1.129 (CAM1_C_P)
/CM4_HighSpeed/CAM1_D0_N: J5.2, Module1.115 (CAM1_D0_N)
/CM4_HighSpeed/CAM1_D0_P: J5.3, Module1.117 (CAM1_D0_P)
/CM4_HighSpeed/CAM1_D1_N: J5.5, Module1.121 (CAM1_D1_N)
/CM4_HighSpeed/CAM1_D1_P: J5.6, Module1.123 (CAM1_D1_P)
/CM4_HighSpeed/CAM1_D2_N: J5.11, Module1.133 (CAM1_D2_N)
/CM4_HighSpeed/CAM1_D2_P: J5.12, Module1.135 (CAM1_D2_P)
/CM4_HighSpeed/CAM1_D3_N: J5.14, Module1.139 (CAM1_D3_N)
/CM4_HighSpeed/CAM1_D3_P: J5.15, Module1.141 (CAM1_D3_P)
/CM4_HighSpeed/DSI0_C_N: J15.8, Module1.169 (DSI0_C_N)
/CM4_HighSpeed/DSI0_C_P: J15.9, Module1.171 (DSI0_C_P)
/CM4_HighSpeed/DSI0_D0_N: J15.2, Module1.157 (DSI0_D0_N)
/CM4_HighSpeed/DSI0_D0_P: J15.3, Module1.159 (DSI0_D0_P)
/CM4_HighSpeed/DSI0_D1_N: J15.5, Module1.163 (DSI0_D1_N)
/CM4_HighSpeed/DSI0_D1_P: J15.6, Module1.165 (DSI0_D1_P)
/CM4_HighSpeed/DSI1_C_N: J16.8, Module1.187 (DSI1_C_N)
/CM4_HighSpeed/DSI1_C_P: J16.9, Module1.189 (DSI1_C_P)
/CM4_HighSpeed/DSI1_D0_N: J16.2, Module1.175 (DSI1_D0_N)
/CM4_HighSpeed/DSI1_D0_P: J16.3, Module1.177 (DSI1_D0_P)
/CM4_HighSpeed/DSI1_D1_N: J16.5, Module1.181 (DSI1_D1_N)
/CM4_HighSpeed/DSI1_D1_P: J16.6, Module1.183 (DSI1_D1_P)
/CM4_HighSpeed/DSI1_D2_N: J16.11, Module1.193 (DSI1_D2_N)
/CM4_HighSpeed/DSI1_D2_P: J16.12, Module1.195 (DSI1_D2_P)
/CM4_HighSpeed/DSI1_D3_N: J16.14, Module1.194 (DSI1_D3_N)
/CM4_HighSpeed/DSI1_D3_P: J16.15, Module1.196 (DSI1_D3_P)
/CM4_HighSpeed/HDMI0_CEC: J22.13 (CEC), Module1.151 (HDMI0_CEC)
/CM4_HighSpeed/HDMI0_CK_N: J22.12 (CK-), Module1.190 (HDMI0_CLK_N)
/CM4_HighSpeed/HDMI0_CK_P: J22.10 (CK+), Module1.188 (HDMI0_CLK_P)
/CM4_HighSpeed/HDMI0_D0_N: J22.9 (D0-), Module1.184 (HDMI0_TX0_N)
/CM4_HighSpeed/HDMI0_D0_P: J22.7 (D0+), Module1.182 (HDMI0_TX0_P)
/CM4_HighSpeed/HDMI0_D1_N: J22.6 (D1-), Module1.178 (HDMI0_TX1_N)
/CM4_HighSpeed/HDMI0_D1_P: J22.4 (D1+), Module1.176 (HDMI0_TX1_P)
/CM4_HighSpeed/HDMI0_D2_N: J22.3 (D2-), Module1.172 (HDMI0_TX2_N)
/CM4_HighSpeed/HDMI0_D2_P: J22.1 (D2+), Module1.170 (HDMI0_TX2_P)
/CM4_HighSpeed/HDMI0_HOTPLUG: J22.19 (HPD/HEAC-), Module1.153 (HDMI0_HOTPLUG)
/CM4_HighSpeed/HDMI0_SCL: J22.15 (SCL), Module1.200 (HDMI0_SCL)
/CM4_HighSpeed/HDMI0_SDA: J22.16 (SDA), Module1.199 (HDMI0_SDA)
/CM4_HighSpeed/HDMI1_CEC: J10.13 (CEC), Module1.149 (HDMI1_CEC)
/CM4_HighSpeed/HDMI1_CK_N: J10.12 (CK-), Module1.166 (HDMI1_CLK_N)
/CM4_HighSpeed/HDMI1_CK_P: J10.10 (CK+), Module1.164 (HDMI1_CLK_P)
/CM4_HighSpeed/HDMI1_D0_N: J10.9 (D0-), Module1.160 (HDMI1_TX0_N)
/CM4_HighSpeed/HDMI1_D0_P: J10.7 (D0+), Module1.158 (HDMI1_TX0_P)
/CM4_HighSpeed/HDMI1_D1_N: J10.6 (D1-), Module1.154 (HDMI1_TX1_N)
/CM4_HighSpeed/HDMI1_D1_P: J10.4 (D1+), Module1.152 (HDMI1_TX1_P)
/CM4_HighSpeed/HDMI1_D2_N: J10.3 (D2-), Module1.148 (HDMI1_TX2_N)
/CM4_HighSpeed/HDMI1_D2_P: J10.1 (D2+), Module1.146 (HDMI1_TX2_P)
/CM4_HighSpeed/HDMI1_HOTPLUG: J10.19 (HPD/HEAC-), Module1.143 (HDMI1_HOTPLUG)
/CM4_HighSpeed/HDMI1_SCL: J10.15 (SCL), Module1.147 (HDMI1_SCL)
/CM4_HighSpeed/HDMI1_SDA: J10.16 (SDA), Module1.145 (HDMI1_SDA)
/CM4_HighSpeed/HDMI_5v: C13.1, J10.18 (+5V), J22.18 (+5V), U12.2 (OUT)
/CM4_HighSpeed/SCL1: J4.20, J6.2, J15.20, R7.2
/CM4_HighSpeed/SDA1: J4.21, J6.4, J15.21, R6.2
/GLOBAL_EN: J1.1, J2.14, Module1.99 (Global_EN), U14.4
/GPIO_VREF: Module1.78 (GPIO_VREF(1.8v/3.3v_Input)), R4.2, R5.2, R6.1, R7.1
/ID_SC: J6.1, J8.28, Module1.35 (ID_SC)
/ID_SD: J6.3, J8.27, Module1.36 (ID_SD)
/PCIE_CLK_N: J12.A14 (REFCLK-), Module1.112 (PCIe_CLK_N)
/PCIE_CLK_P: J12.A13 (REFCLK+), Module1.110 (PCIe_CLK_P)
/PCIE_CLK_nREQ: J12.B12 (nCLKREQ), Module1.102 (PCIe_CLK_nREQ)
/PCIE_RX_N: J12.A16 (PERP0), Module1.118 (PCIe_RX_N)
/PCIE_RX_P: J12.A17 (PERN0), Module1.116 (PCIe_RX_P)
/PCIE_TX_N: J12.B14 (PETP0), Module1.124 (PCIe_TX_N)
/PCIE_TX_P: J12.B15 (PETN0), Module1.122 (PCIe_TX_P)
/PCIE_nRST: J12.A11 (nPERST), Module1.109 (PCIe_nRST)
/PCIe-connector/+3.3v: C30.1, C31.1, C32.1, C33.1, C45.1, C65.1, J12.A5 (TCK), J12.A6 (TDI), J12.A8 (TMS), J12.A9 (+3.3V), J12.A10 (+3.3V), J12.B8 (+3.3v), J12.B9 (nTRST), J12.B10 (+3.3vAUX), L3.2, R24.1, TP1.1
/RTC , Wakeup, FAN/nRTC_INT: C24.2, R19.1, U8.3 (~INT~)
/SCL0: J5.20, J16.20, Module1.80 (SCL0), U8.6 (SCL), U11.2 (SCL)
/SDA0: J5.21, J16.21, Module1.82 (SDA0), U8.5 (SDA), U11.1 (SDA)
/TV_OUT: J2.11, Module1.111 (VDAC_COMP)
/USB2-HUB/HD1_N: J13.2 (D-`), U6.1 (USBDM_DN1/PRT_DIS_M1)
/USB2-HUB/HD1_P: J13.3 (D+`), U6.2 (USBDP_DN1/PRT_DIS_P1)
/USB2-HUB/HD2_N: J13.6 (D-), U6.3 (USBDM_DN2/PRT_DIS_M2)
/USB2-HUB/HD2_P: J13.7 (D+), U6.4 (USBDP_DN2/PRT_DIS_P2)
/USB2-HUB/HD3_N: J14.3, U6.6 (USBDM_DN3/PRT_DIS_M3)
/USB2-HUB/HD3_P: J14.5, U6.7 (USBDP_DN3/PRT_DIS_P3)
/USB2-HUB/HD4_N: J14.4, U6.8 (USBDM_DN4/PRT_DIS_M4)
/USB2-HUB/HD4_P: J14.6, U6.9 (USBDP_DN4/PRT_DIS_P4)
/USB2-HUB/PWR1: U6.12 (PRTPWR1/BC_EN1), U7.3 (EN)
/USB2-HUB/USBD_N: J11.2 (D-), U4.4 (D2+), U4.7, U13.8 (HSD1_M)
/USB2-HUB/USBD_P: J11.3 (D+), U4.5 (D2-), U4.6, U13.9 (HSD1_P)
/USB2-HUB/USBH_N: U6.30 (USBDM_UP), U13.6 (HSD0_M)
/USB2-HUB/USBH_P: U6.31 (USBDP_UP), U13.7 (HSD0_P)
/USB2-HUB/VBUS: C16.1, C17.1, C19.1, C20.1, C21.1, J13.1 (VBUS`), J13.5 (VBUS), J14.1, J14.2, U7.6 (OUT)
/USB2-HUB/nOCS1: U6.13 (OCS_N1), U6.17 (OCS_N2), U6.19 (OCS_N3), U6.21 (OCS_N4), U7.4 (nFault)
/USB2_N: Module1.103 (USB2_N), U13.4 (D_N)
/USB2_P: Module1.105 (USB2_P), U13.3 (D_P)
/USBOTG: Module1.101 (USB_OTG_ID), R8.2, R11.1, U13.2 (SEL)
/nEXTRST: Module1.100 (nEXTRST), U6.26 (RESET_N)
GND: BT1.2 (-), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.2, C22.2, C23.2, C25.2, C26.2, C27.2, C28.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C49.2, C51.2, C52.2, C58.2, C59.2, C60.2, C62.2, C63.2, C64.2, J1.2, J2.1, J2.3, J2.7, J2.10, J2.12, J3.2, J4.1, J4.4, J4.7, J4.10, J4.13, J4.16, J4.19, J5.1, J5.4, J5.7, J5.10, J5.13, J5.16, J5.19, J7.6 (VSS), J7.11 (SHIELD), J8.6, J8.9, J8.14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
unnamed: BT1.1 (+), D3.1
unnamed: C1.1, U3.4 (CT), U3.5 (CT)
unnamed: C8.1, U6.33 (XTALIN/CLKIN), Y1.1
unnamed: C9.1, U6.32 (XTALOUT), Y1.2
unnamed: C24.1, R20.1, U14.2
unnamed: C29.1, R22.2
unnamed: C29.2, U15.1 (BST)
unnamed: C36.1, J19.1, Q1.5 (D)
unnamed: C40.2, D4.2 (A), Q1.4 (G), R26.1
unnamed: C46.1, D3.3, U8.8 (VDD)
unnamed: C57.1, R9.2
unnamed: C57.2, U16.1 (BST)
unnamed: C58.1, U16.4 (SS)
unnamed: C59.1, R25.1, U16.6 (COMP)
unnamed: C60.1, R25.2
unnamed: C61.2, R27.2, R28.1, U16.5 (FB)
unnamed: C62.1, U15.4 (SS)
unnamed: C63.1, R23.1, U15.6 (COMP)
unnamed: C64.1, R23.2
unnamed: C65.2, R24.2, R30.1, U15.5 (FB)
unnamed: D1.1 (K), R10.1, TP5.1
unnamed: D2.1 (K), R1.1, TP3.1
unnamed: J2.13, U9.4
unnamed: J7.9 (DET_B), R18.2
unnamed: J7.10 (DET_A), R17.2
unnamed: J11.1 (VBUS), R8.1
unnamed: J17.3, R21.1, U11.6 (TACH)
unnamed: J17.4, U11.5 (PWM)
unnamed: L3.1, R22.1, U15.8 (SW)
unnamed: L5.1, R9.1, U16.8 (SW)
unnamed: Module1.21 (PI_nLED_Activity), R1.2
unnamed: R2.1, U3.16 (LEDY_K)
unnamed: R3.1, U3.18 (LEDG_K)
unnamed: R10.2, U5.4
unnamed: R12.1, U6.24 (SCL/SMBCLK/CFG_SEL0)
unnamed: R13.1, U6.22 (SDA/SMBDATA/NON_REM1)
unnamed: R14.1, U6.28 (SUSP_IND/LOCAL_PWR/NON_REM0)
unnamed: R15.2, U6.35 (RBIAS)
unnamed: R16.1, U6.25 (HS_IND/CFG_SEL1)
unnamed: R36.1, U7.5 (ILIM)
unnamed: U4.1 (D1+), U4.10
unnamed: U4.2 (D1-), U4.9
unnamed: U8.1 (OSCI), Y2.2
unnamed: U8.2 (OSCO), Y2.1

Notices in the files:
AP2000/AP2000.kicad_pcb:
Copyright 2021
parts and their libraries:
Copyright 2021 Accelerated Designs. All rights reserved.
